# Keil uVision project stm32f10x_scom.uvprojx, settings and files
target stm32f10x_scom (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x_scom +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\my_drivers\inc;..\project;..\my_drivers\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
    ./: system_stm32f10x.c stm32f10x_it.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_exti.c
  group my_drivers
    ../my_drivers/src/: stm32f10x_scom.c test.c stm32f10x_scom_it.c delay.c stm32f10x_OLED_I2C.c stm32f10x_STMADC.c stm32f10x_pwm.c stm32f10x_capture.c stm32f10x_encoder.c control.c stm32f10x_keyExti.c
    ../my_drivers/inc/: stm32f10x_pwm.h
  group HARDWARE
    ../HARDWARE/: stm32f10x_scom_hardwaretable.c stm32f10x_STMADC_Hardwaretable.c stm32f10x_encoder_hardwaretable.c stm32f10x_pwm_hardwaretable.c
